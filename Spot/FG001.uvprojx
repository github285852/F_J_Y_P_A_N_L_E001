# Keil uVision project FG001.uvprojx, settings and files
target SPOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FG001 +hex
  AfterMake: D:\program\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\Project\Objects\filmgear001.bin ..\Project\Objects\FG001.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_STM3210C_EVAL,SPOT
  c include: ..\Source\APP;..\Source\CORE;..\Source\Driver;..\Source\HAL;..\Source\STM32F10x_FWLib\inc;..\Source\USER;..\Source\STM32_USB_HOST_Library\Core\inc;..\Source\STM32_USB_HOST_Library\Class\MSC\inc;..\Source\STM32_USB_OTG_Driver\inc;..\Source\fat_fs\inc;..\Source\spot
  memory RVCT4: ROM 0x800c800 size 0x33800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../Source/USER/: main.c
    ../Source/CORE/: core_cm3.c startup_stm32f10x_cl.s
  group user
    ../Source/USER/: stm32f10x_it.c system_stm32f10x.c usbh_conf.h usb_conf.h
    ../Source/APP/: includes.h
  group Lib
    ../Source/STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c
  group driver
    ../Source/Driver/: key.c menu.c menu_handle.c picture_data.c scheduler.c st7735s.c graphical.c malloc.c dmxprotocol.c font.h gbk_font.h mymath.c
  group app
    ../Source/Driver/: usbh_usr.c
    ../Source/APP/: color_light.c filmgear_data.c scene.c algorithm_test.c
  group hal
    ../Source/Driver/: usb_bsp.c
    ../Source/HAL/: adc.c dmx512.c ec11.c ledpower.c myiic.c stmflash.c spi.c sys.c delay.c uart3.c timer.c wdg.c debug.c
  group FAT_FS
    ../Source/fat_fs/src/: ff.c fattime.c
    ../Source/fat_fs/src/option/: ccsbcs.c
  group usb_host
    ../Source/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Source/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../Source/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group spot
    ../Source/spot/: spot_gui.c spot_color_light.c spot.c spot_menutask.c
