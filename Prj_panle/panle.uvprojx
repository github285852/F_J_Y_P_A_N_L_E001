# Keil uVision project panle.uvprojx, settings and files
target PANLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: panle
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_STM3210C_EVAL,PANLE
  c include: ..\Source\APP;..\Source\CORE;..\Source\Driver;..\Source\fat_fs\inc;..\Source\HAL;..\Source\fat_fs\inc;..\Source\panle;..\Source\STM32_USB_HOST_Library\Class\MSC\inc;..\Source\STM32_USB_HOST_Library\Core\inc;..\Source\STM32_USB_OTG_Driver\inc;..\Source\STM32F10x_FWLib\inc;..\Source\USER
  memory RVCT4: ROM 0x800c800 size 0x33800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../Source/USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../Source/APP/: algorithm_test.c color_light.c filmgear_data.c scene.c
    ../Source/Driver/: usbh_usr.c
  group DRIVER
    ../Source/Driver/: dmxprotocol.c graphical.c key.c malloc.c menu.c menu_handle.c mymath.c st7735s.c scheduler.c picture_data.c
  group HAL
    ../Source/HAL/: adc.c debug.c delay.c dmx512.c ec11.c ledpower.c stmflash.c sys.c timer.c uart3.c wdg.c spi.c
    ../Source/Driver/: usb_bsp.c
  group LIB
    ../Source/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group FAT_FS
    ../Source/fat_fs/src/: ff.c fattime.c
    ../Source/fat_fs/src/option/: ccsbcs.c
  group USB_H
    ../Source/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../Source/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Source/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
  group PANLE
    ../Source/panle/: panle.c panle_gui.c panle_menutask.c
  group CORE
    ../Source/CORE/: core_cm3.c startup_stm32f10x_cl.s
